# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\Soft\485;..\Soft\can;..\Soft\led;..\System\delay;..\System\sys;..\Soft\tim;..\Soft\TMR;..\Soft\key;..\Soft\pwm;..\Soft\light
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group Soft
    ../Soft/led/: led.c
    ../Soft/tim/: timer.c
    ../Soft/TMR/: tmr.c
    ../Soft/key/: key.c
    ../Soft/pwm/: pwm.c
    ../Soft/light/: light.c
  group FWlib
    ../FWlib/src/: stm32f10x_tim.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group System
    ../System/sys/: sys.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
